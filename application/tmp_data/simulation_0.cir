Memristor Random network
.include ../models/pershin.sub
V1 vin gnd pwl (1e-09 -6.283185307179586e-08 0.003003004002002002 -0.18867311060245615 0.006006007004004004 -0.37727898944859173 0.009009010006006006 -0.5657505543807598 0.012012013008008008 -0.7540207082261373 0.01501501601001001 -0.9420224255156322 0.018018019012012013 -1.1296887763454122 0.021021022014014012 -1.3169529502044104 0.024024025016016016 -1.5037482797593262 0.02702702801801802 -1.6900082645886543 0.03003003102002002 -1.8756665948572921 0.03303303402202202 -2.060657174923297 0.036036037024024026 -2.24491414686839 0.039039040026026026 -2.428371913943825 0.042042043028028026 -2.6109651639232845 0.04504504603003003 -2.7926288923544815 0.04804804903203203 -2.9732984257011896 0.05105105203403403 -3.1529094443674666 0.05405405503603604 -3.3313980055958763 0.05705705803803804 -3.5087005662315427 0.06006006104004004 -3.68475400534396 0.06306306404204204 -3.859495646698466 0.06606606704404404 -4.032863281069424 0.06906907004604605 -4.204795188387127 0.07207207304804805 -4.375230159710569 0.07507507605005005 -4.544107519018249 0.07807807905205205 -4.7113671448092544 0.08108108205405405 -4.876949491506924 0.08408408505605605 -5.040795610657484 0.08708708805805807 -5.2028471719161065 0.09009009106006007 -5.363046483812905 0.09309309406206207 -5.521336514291509 0.09609609706406406 -5.6776609110128495 0.09909910006606606 -5.831964021416992 0.10210210306806806 -5.984190912535828 0.10510510607007006 -6.134287390549589 0.10810810907207208 -6.282200020080214 0.11111111207407408 -6.42787614321472 0.11411411507607608 -6.57126389825177 0.11711711807807808 -6.71231223816481 0.12012012108008008 -6.850970948775151 0.12312312408208208 -6.98719066662856 0.12612612708408408 -7.120922896568995 0.1291291300860861 -7.2521200290032155 0.13213213308808808 -7.380735356850115 0.1351351360900901 -7.506723092168777 0.1381381390920921 -7.630038382459283 0.1411411420940941 -7.750637326630519 0.1441441450960961 -7.8684769906292695 0.1471471480980981 -7.983515422725017 0.1501501511001001 -8.095711668445075 0.1531531541021021 -8.205025785154632 0.1561561571041041 -8.311418856276632 0.15915916010610612 -8.414853005146316 0.1621621631081081 -8.515291408495598 0.16516516611011012 -8.612698309562392 0.1681681691121121 -8.70703903082026 0.17117117211411412 -8.79827998632386 0.17417417511611613 -8.886388693665774 0.17717717811811812 -8.971333785540448 0.18018018112012013 -9.0530850209112 0.18318318412212212 -9.131613295776207 0.18618618712412413 -9.206890653529754 0.18918919012612612 -9.27889029491496 0.19219219312812813 -9.34758658756451 0.19519519613013014 -9.412955075125947 0.19819819913213213 -9.474972485968301 0.20120120213413414 -9.533616741466952 0.20420420513613613 -9.588866963863776 0.20720720813813814 -9.640703483699767 0.21021021114014013 -9.68910784681749 0.21321321414214214 -9.73406282093091 0.21621621714414416 -9.775552401760185 0.21921922014614614 -9.813561818729305 0.22222222314814816 -9.848077540224523 0.22522522615015014 -9.879087278411694 0.22822822915215216 -9.906579993610837 0.23123123215415417 -9.93054589822634 0.23423423515615616 -9.950976460231391 0.23723723815815817 -9.967864406205466 0.24024024116016016 -9.981203723923691 0.24324324416216217 -9.990989664497258 0.24624624716416416 -9.997218744064044 0.24924925016616617 -9.9998887450289 0.2522522531681682 -9.998998716853126 0.2552552561701702 -9.994548976392872 0.2582582591721722 -9.986541107786332 0.2612612621741742 -9.974977961889785 0.2642642651761762 -9.95986365526266 0.2672672681781782 -9.94120356870203 0.2702702711801802 -9.919004345326991 0.2732732741821822 -9.893273888213683 0.27627627718418424 -9.864021357581729 0.2792792801861862 -9.83125716753314 0.2822822831881882 -9.79499298234482 0.2852852861901902 -9.755241712316007 0.28828828919219224 -9.712017509172114 0.29129129219419425 -9.665335761026618 0.2942942951961962 -9.615213086902788 0.2972972981981982 -9.561667330817196 0.30030030120020024 -9.504717555427124 0.30330330420220225 -9.444384035244134 0.3063063072042042 -9.38068824941619 0.3093093102062062 -9.313652874080944 0.31231231320820824 -9.24330177429287 0.31531531621021025 -9.169659995527148 0.31831831921221226 -9.092753754763287 0.3213213222142142 -9.01261043115172 0.32432432521621624 -8.929258556266618 0.32732732821821825 -8.842727803948472 0.33033033122022026 -8.753048979739992 0.3333333342222223 -8.660254009919116 0.33633633722422424 -8.564375930133057 0.33933934022622625 -8.465448873637357 0.34234234322822826 -8.363508059144234 0.3453453462302303 -8.258589778284474 0.3483483492322323 -8.150731382687354 0.35135135223423425 -8.03997127068322 0.35435435523623626 -7.926348873633392 0.3573573582382383 -7.80990464189236 0.3603603612402403 -7.690680030407151 0.36336336424224225 -7.568717483959108 0.36636636724424426 -7.444060422053228 0.3693693702462463 -7.316753223460548 0.3723723732482483 -7.186841210418985 0.3753753762502503 -7.054370632498296 0.37837837925225226 -6.919388650134937 0.3813813822542543 -6.781943317842599 0.3843843852562563 -6.642083567104495 0.3873873882582583 -6.499859188953401 0.3903903912602603 -6.355320816245697 0.3933933942622623 -6.208519905635748 0.3963963972642643 -6.0595087192569554 0.3993994002662663 -5.908340306116097 0.4024024032682683 -5.755068483207509 0.40540540627027033 -5.599747816353858 0.4084084092722723 -5.442433600780349 0.4114114122742743 -5.283181841429228 0.4144144152762763 -5.122049233021652 0.41741741827827833 -4.959093139873973 0.4204204212802803 -4.794371575475651 0.4234234242822823 -4.627943181836028 0.4264264272842843 -4.459867208607411 0.42942943028628633 -4.290203491991762 0.43243243328828834 -4.119012433438602 0.4354354362902903 -3.946354978141688 0.4384384392922923 -3.7722925933420894 0.44144144229429433 -3.5968872464454376 0.44444444529629634 -3.420201382961112 0.44744744829829836 -3.242297904271196 0.4504504513003003 -3.0632401452371605 0.45345345430230233 -2.883091851652207 0.45645645730430434 -2.7019171575473333 0.45945946030630636 -2.519780562359189 0.46246246330830837 -2.336746907967816 0.4654654663103103 -2.152881355612504 0.46846846931231234 -1.968249362693931 0.47147147231431435 -1.782916659470881 0.47447447531631637 -1.5969492256598348 0.4774774783183183 -1.410413266945725 0.48048048132032034 -1.2233751914122462 0.48348348432232235 -1.0359015859001492 0.48648648732432437 -0.8480591923018339 0.4894894903263264 -0.659914883800808 0.49249249332832834 -0.47153564106435963 0.49549549633033035 -0.2829885283979671 0.49849849933233237 -0.09434066986997515 0.5015015023343343 -0.09434077458506535 0.5045045053363363 -0.28298863307577804 0.5075075083383384 -0.47153574566762974 0.5105105113403403 -0.6599149882922932 0.5135135143423423 -0.8480592966443302 0.5165165173443443 -1.0359016900565143 0.5195195203463463 -1.2233752953453998 0.5225225233483484 -1.4104133706186708 0.5255255263503503 -1.5969493290356596 0.5285285293523523 -1.7829167625127784 0.5315315323543544 -1.9682494653652258 0.5345345353563563 -2.1528814578766364 0.5375375383583584 -2.336747009788391 0.5405405413603603 -2.519780663699946 0.5435435443623623 -2.7019172583721938 0.5465465473643644 -2.883091951925285 0.5495495503663663 -3.063240244922754 0.5525525533683684 -3.242298003333821 0.5555555563703704 -3.420201481365493 0.5585585593723723 -3.596887344156542 0.5615615623743744 -3.772292690325139 0.5645645653763763 -3.9463550743621525 0.5675675683783784 -4.11901252886223 0.5705705713803804 -4.290203586584575 0.5735735743823823 -4.4598673023357325 0.5765765773843844 -4.627943274666498 0.5795795803863864 -4.794371667375213 0.5825825833883884 -4.9590932308099225 0.5855855863903904 -5.122049322961604 0.5885885893923923 -5.283181930341162 0.5915915923943944 -5.44243368863262 0.5945945953963964 -5.599747903115185 0.5975975983983984 -5.755068568847007 0.6006006014004004 -5.908340390603275 0.6036036044024023 -6.059508802561733 0.6066066074044044 -6.208519987728475 0.6096096104064064 -6.355320897097144 0.6126126134084083 -6.499859268534783 0.6156156164104104 -6.642083645387485 0.6186186194124124 -6.781943394799322 0.6216216224144144 -6.919388725738002 0.6246246254164164 -7.054370706720784 0.6276276284184183 -7.186841283234471 0.6306306314204204 -7.316753294843115 0.6336336344224224 -7.444060491977456 0.6366366374244244 -7.568717552400106 0.6396396404264264 -7.690680097340556 0.6426426434284284 -7.809904707294338 0.6456456464304304 -7.926348937480668 0.6486486494324324 -8.039971332953057 0.6516516524344345 -8.150731443357591 0.6546546554364364 -8.258589837333504 0.6576576584384384 -8.363508116551037 0.6606606614404404 -8.4654489293815 0.6636636644424424 -8.56437598419469 0.6666666674444445 -8.660254062278995 0.6696696704464464 -8.75304903037947 0.6726726734484484 -8.842727852849526 0.6756756764504505 -8.929258603411842 0.6786786794524524 -9.012610476524326 0.6816816824544545 -9.092753798347127 0.6846846854564564 -9.1696600373067 0.6876876884584584 -9.243301814253265 0.6906906914604605 -9.313652912207953 0.6936936944624624 -9.38068828569624 0.6966966974644645 -9.444384069664308 0.6996997004664665 -9.504717587975168 0.7027027034684684 -9.561667361481522 0.7057057064704705 -9.615213115672484 0.7087087094724724 -9.665335787891438 0.7117117124744745 -9.712017534122495 0.7147147154764765 -9.755241735343066 0.7177177184784784 -9.794993003440359 0.7207207214804805 -9.831257186689651 0.7237237244824825 -9.864021374792388 0.7267267274844844 -9.893273903472366 0.7297297304864865 -9.919004358628268 0.7327327334884884 -9.94120358004116 0.7357357364904905 -9.95986366463561 0.7387387394924925 -9.974977969293215 0.7417417424944944 -9.98654111321761 0.7447447454964965 -9.994548979850062 0.7477477484984985 -9.998998718334999 0.7507507515005005 -9.999888744534926 0.7537537545025025 -9.997218741594402 0.7567567575045044 -9.990989660052826 0.7597597605065065 -9.981203717506052 0.7627627635085085 -9.967864397816902 0.7657657665105105 -9.95097644987489 0.7687687695125125 -9.930545885905588 0.7717717725145145 -9.906579979330225 0.7747747755165165 -9.879087262176299 0.7777777785185185 -9.848077522040128 0.7807807815205206 -9.813561798602384 0.7837837845225225 -9.775552379697904 0.7867867875245245 -9.734062796941124 0.7897897905265265 -9.689107820908736 0.7927927935285285 -9.640703455881269 0.7957957965305306 -9.588866934145443 0.7987987995325325 -9.533616709859361 0.8018018025345345 -9.474972452482703 0.8048048055365365 -9.412955039774264 0.8078078085385385 -9.34758655035933 0.8108108115405406 -9.278890255869522 0.8138138145425425 -9.206890612657961 0.8168168175445445 -9.131613253092613 0.8198198205465466 -9.053084976430995 0.8228228235485485 -8.971333739279473 0.8258258265505505 -8.886388645640494 0.8288288295525525 -8.79827993655138 0.8318318325545545 -8.707038979318293 0.8348348355565566 -8.612698256349269 0.8378378385585585 -8.51529135359027 0.8408408415605605 -8.41485294856833 0.8438438445625626 -8.311418798046121 0.8468468475645645 -8.205025725292339 0.8498498505665666 -8.0957116069723 0.8528528535685685 -7.983515359663653 0.8558558565705705 -7.8684769260017635 0.8588588595725726 -7.750637260459884 0.8618618625745745 -7.630038314769072 0.8648648655765766 -7.506723022983083 0.8678678685785786 -7.380735286193576 0.8708708715805805 -7.252119956900984 0.8738738745825826 -7.120922823046736 0.8768768775845845 -6.987190591712452 0.8798798805865866 -6.850970872491859 0.8828828835885886 -6.712312160541499 0.8858858865905905 -6.571263819316072 0.8888888895925926 -6.427876062994736 0.8918918925945946 -6.282199938604506 0.8948948955965966 -6.134287307847156 0.8978978985985986 -5.98419082863612 0.9009009016006005 -5.831963936349876 0.9039039046026026 -5.677660824808601 0.9069069076046046 -5.521336426980827 0.9099099106066066 -5.363046395426867 0.9129129136086086 -5.202847082486182 0.9159159166106106 -5.040795520215514 0.9189189196126126 -4.876949400085097 0.9219219226146146 -4.711367052440126 0.9249249256166167 -4.544107425734703 0.9279279286186186 -4.375230065545814 0.9309309316206206 -4.204795093374687 0.9339339346226226 -4.032863185243117 0.9369369376246246 -3.8594955500924137 0.9399399406266266 -3.6847539079925546 0.9429429436286286 -3.508700468169435 0.9459459466306306 -3.331397906857984 0.9489489496326327 -3.152909344988934 0.9519519526346346 -2.9732983257174035 0.9549549556366366 -2.7926287918010373 0.9579579586386386 -2.6109650628359797 0.9609609616406406 -2.4283718123586477 0.9639639646426427 -2.2449140448214964 0.9669669676446446 -2.0606570724510256 0.9699699706466466 -1.8756664919961228 0.9729729736486487 -1.690008161375198 0.9759759766506506 -1.5037481762303369 0.9789789796526527 -1.316952846396736 0.9819819826546546 -1.1296886722960175 0.9849849856566566 -0.9420223212615597 0.9879879886586587 -0.7540206038045022 0.9909909916606606 -0.565750449828737 0.9939939946626627 -0.37727888480339344 0.9969969976646647 -0.18867300590134573 1.0000000006666667 -4.188790402745163e-08 1.0030030036686688 -0.18867308966224142 1.0060060066706709 -0.37727896851955733 1.0090090096726727 -0.5657505334703566 1.0120120126746748 -0.7540206873418094 1.0150150156766768 -0.9420224046648236 1.0180180186786787 -1.1296887555355282 1.0210210216806808 -1.3169529294428772 1.0240240246826828 -1.5037482590535347 1.0270270276846847 -1.6900082439459587 1.0300300306866867 -1.8756665742850587 1.0330330336886888 -2.06065715442885 1.0360360366906909 -2.2449141264590162 1.0390390396926927 -2.4283718936267906 1.0420420426946948 -2.610965143705823 1.0450450456966969 -2.7926288722437986 1.0480480486986987 -2.9732984057044276 1.0510510517007008 -3.152909424491762 1.0540540547027029 -3.331397985848304 1.0570570577047047 -3.5087005466191172 1.0600600607067068 -3.6847539858736793 1.0630630637087088 -3.8594956273772625 1.066066066710711 -4.0328632619041755 1.0690690697127128 -4.20479516938464 1.0720720727147148 -4.375230140877625 1.075075075716717 -4.544107500361545 1.0780780787187187 -4.711367126335425 1.0810810817207208 -4.87694947322256 1.0840840847227229 -5.040795592569095 1.0870870877247247 -5.202847154030117 1.0900900907267268 -5.3630464661357005 1.0930930937287289 -5.521336496829379 1.096096096730731 -5.6776608937720106 1.0990990997327328 -5.83196400440357 1.1021021027347349 -5.984190895755894 1.105105105736737 -6.134287374009108 1.1081081087387388 -6.282200003785075 1.1111111117407408 -6.427876127170721 1.114114114742743 -6.571263882464635 1.1171171177447448 -6.712312222640145 1.1201201207467468 -6.850970933518495 1.123123123748749 -6.987190651645343 1.1261261267507507 -7.120922881864541 1.1291291297527528 -7.25212001458277 1.1321321327547549 -7.380735342718813 1.135135135756757 -7.506723078331642 1.1381381387587588 -7.630038368921243 1.1411411417607609 -7.7506373133963935 1.144144144762763 -7.868476977703772 1.1471471477647648 -7.983515410112743 1.1501501507667669 -8.095711656150522 1.153153153768769 -8.205025773182179 1.1561561567707708 -8.311418844630527 1.1591591597727728 -8.414852993830719 1.162162162774775 -8.515291397514536 1.165165165776777 -8.61269829891977 1.1681681687787788 -8.707039020519868 1.171171171780781 -8.798279976369365 1.174174174782783 -8.886388684060721 1.1771771777847848 -8.971333776288251 1.1801801807867869 -9.053085012015158 1.183183183788789 -9.131613287239492 1.1861861867907908 -9.206890645355394 1.1891891897927929 -9.278890287105874 1.192192192794795 -9.347586580123478 1.195195195796797 -9.412955068055613 1.1981981987987989 -9.474972479271182 1.201201201800801 -9.533616735145433 1.204204204802803 -9.58886695792011 1.2072072078048048 -9.640703478136066 1.210210210806807 -9.68910784163574 1.213213213808809 -9.734062816132955 1.2162162168108108 -9.77555239734773 1.219219219812813 -9.813561814703922 1.222222222814815 -9.848077536587645 1.2252252258168168 -9.879087275164615 1.2282282288188189 -9.906579990754716 1.231231231820821 -9.93054589576219 1.234234234822823 -9.950976458160092 1.2372372378248249 -9.967864404527752 1.240240240826827 -9.981203722640164 1.243243243828829 -9.990989663608373 1.2462462468308309 -9.997218743570116 1.249249249832833 -9.999888744930105 1.252252252834835 -9.9989987171495 1.2552552558368368 -9.99454897708431 1.258258258838839 -9.986541108872588 1.261261261840841 -9.974977963370469 1.264264264842843 -9.95986365713725 1.267267267844845 -9.941203570969856 1.270270270846847 -9.919004347987247 1.273273273848849 -9.893273891265418 1.2762762768508509 -9.86402136102386 1.279279279852853 -9.831257171364442 1.282282282854855 -9.794992986563926 1.2852852858568569 -9.75524171692142 1.288288288858859 -9.71201751416219 1.291291291860861 -9.665335766399581 1.294294294862863 -9.615213092656724 1.297297297864865 -9.56166733695006 1.300300300866867 -9.504717561936731 1.303303303868869 -9.444384042128164 1.306306306870871 -9.380688256672197 1.309309309872873 -9.313652881706341 1.312312312874875 -9.24330178228495 1.315315315876877 -9.169660003883056 1.318318318878879 -9.092753763480058 1.321321321880881 -9.01261044022624 1.3243243248828829 -8.929258565695669 1.327327327884885 -8.842727813728686 1.330330330886887 -8.753048989867887 1.333333333888889 -8.66025402039109 1.336336336890891 -8.564375940945386 1.339339339892893 -8.465448884786184 1.342342342894895 -8.36350807062559 1.345345345896897 -8.258589790094282 1.348348348898899 -8.1507313948214 1.351351351900901 -8.03997128313718 1.354354354902903 -7.92634888640285 1.357357357904905 -7.809904654972755 1.360360360906907 -7.690680043793828 1.363363363908909 -7.568717497647296 1.366366366910911 -7.444060436038072 1.369369369912913 -7.316753237737056 1.372372372914915 -7.186841224982084 1.375375375916917 -7.0543706473427905 1.378378378918919 -6.9193886652555525 1.381381381920921 -6.781943333233945 1.384384384922923 -6.642083582761104 1.387387387924925 -6.499859204869681 1.390390390926927 -6.355320832415986 1.3933933939289291 -6.208519922054286 1.396396396930931 -6.059508735917914 1.399399399932933 -5.908340323013532 1.4024024029349351 -5.755068500335402 1.405405405936937 -5.599747833706128 1.408408408938939 -5.4424336183508 1.411411411940941 -5.283181859211608 1.414414414942943 -5.122049251009647 1.417417417944945 -4.959093158061163 1.420420420946947 -4.794371593855553 1.4234234239489492 -4.627943200402107 1.426426426950951 -4.459867227353072 1.429429429952953 -4.290203510910317 1.4324324329549551 -4.119012452523315 1.435435435956957 -3.946354997385777 1.438438438958959 -3.7722926127387035 1.4414414419609611 -3.59688726598766 1.444444444962963 -3.420201402642001 1.447447447964965 -3.2422979240837284 1.4504504509669671 -3.0632401651742796 1.453453453968969 -2.883091871706831 1.456456456970971 -2.7019171777123105 1.459459459972973 -2.5197805826273405 1.4624624629749752 -2.3367469283319258 1.465465465976977 -2.152881376065336 1.468468468978979 -1.9682493832281858 1.4714714719809812 -1.7829166800792529 1.474474474982983 -1.5969492463350043 1.477477477984985 -1.4104132876803102 1.4804804809869871 -1.2233752121988692 1.483483483988989 -1.0359016067314233 1.486486486990991 -0.84805921317033 1.4894894899929931 -0.6599149046990964 1.4924924929949952 -0.4715356619849962 1.495495495996997 -0.282988549333526 1.4984984989989991 -0.09434069081298102 1.5015015020010012 -0.09434075364205058 1.504504505003003 -0.282988612140228 1.507507508005005 -0.471535724746971 1.5105105110070072 -0.6599149673940002 1.513513514009009 -0.8480592757758254 1.516516517011011 -1.03590166922524 1.5195195200130132 -1.223375274558777 1.5225225230150152 -1.41041334988409 1.525525526017017 -1.5969493083604944 1.5285285290190191 -1.7829167419044065 1.5315315320210212 -1.9682494448309753 1.534534535023023 -2.152881437423813 1.5375375380250251 -2.336746989424281 1.5405405410270272 -2.5197806434318073 1.543543544029029 -2.7019172382072254 1.5465465470310311 -2.8830919318706734 1.5495495500330332 -3.0632402249856483 1.552552553035035 -3.2422979835212966 1.555555556037037 -3.420201461684625 1.5585585590390392 -3.596887324614337 1.5615615620410412 -3.772292670928529 1.564564565043043 -3.9463550551180675 1.5675675680450452 -4.119012509777501 1.5705705710470472 -4.2902035676660155 1.573573574049049 -4.459867283590063 1.5765765770510511 -4.627943256100399 1.5795795800530532 -4.794371648995304 1.582582583055055 -4.959093212622725 1.5855855860570571 -5.122049304973613 1.5885885890590592 -5.283181912558782 1.5915915920610613 -5.442433671062173 1.5945945950630631 -5.59974788576292 1.5975975980650652 -5.75506855171911 1.6006006010670673 -5.908340373705849 1.603603604069069 -6.05950878590078 1.6066066070710712 -6.208519971309933 1.6096096100730732 -6.355320880926865 1.612612613075075 -6.499859252618508 1.6156156160770772 -6.642083629730894 1.6186186190790792 -6.7819433794079895 1.6216216220810813 -6.919388710617401 1.6246246250830831 -7.054370691876293 1.6276276280850852 -7.1868412686713725 1.6306306310870873 -7.316753280566605 1.6336336340890891 -7.444060477992607 1.6366366370910912 -7.568717538711906 1.6396396400930933 -7.690680083953881 1.6426426430950951 -7.809904694213942 1.6456456460970972 -7.926348924711213 1.6486486490990993 -8.039971320499093 1.651651652101101 -8.150731431223539 1.6546546551031032 -8.258589825523698 1.6576576581051052 -8.36350810506968 1.6606606611071073 -8.465448918232676 1.6636636641091092 -8.564375973382363 1.6666666671111112 -8.660254051807023 1.6696696701131133 -8.753049020251582 1.6726726731151151 -8.84272784306932 1.6756756761171172 -8.929258593982802 1.6786786791191193 -9.012610467449813 1.6816816821211211 -9.09275378963036 1.6846846851231232 -9.169660028950794 1.6876876881251253 -9.243301806261192 1.6906906911271273 -9.31365290458255 1.6936936941291292 -9.380688278440232 1.6966966971311312 -9.444384062780273 1.6996997001331333 -9.504717581465563 1.7027027031351352 -9.561667355348657 1.7057057061371372 -9.615213109918544 1.7087087091391393 -9.665335782518476 1.7117117121411412 -9.712017529132417 1.7147147151431432 -9.755241730737655 1.7177177181451453 -9.794992999221252 1.7207207211471474 -9.83125718285835 1.7237237241491492 -9.864021371350256 1.7267267271511513 -9.893273900420631 1.7297297301531533 -9.919004355968013 1.7327327331551552 -9.941203577773335 1.7357357361571573 -9.959863662761022 1.7387387391591593 -9.974977967812531 1.7417417421611612 -9.986541112131356 1.7447447451631632 -9.994548979158624 1.7477477481651653 -9.998998718038624 1.7507507511671674 -9.999888744633722 1.7537537541691692 -9.99721874208833 1.7567567571711713 -9.990989660941713 1.7597597601731734 -9.98120371878958 1.7627627631751752 -9.967864399494616 1.7657657661771773 -9.950976451946191 1.7687687691791794 -9.930545888369739 1.7717717721811812 -9.906579982186347 1.7747747751831833 -9.879087265423378 1.7777777781851853 -9.848077525677006 1.7807807811871872 -9.81356180262777 1.7837837841891893 -9.77555238411036 1.7867867871911913 -9.73406280173908 1.7897897901931934 -9.689107826090485 1.7927927931951952 -9.64070346144497 1.7957957961971973 -9.588866940089106 1.7987987991991994 -9.533616716180873 1.8018018022012012 -9.47497245917982 1.8048048052032033 -9.412955046844598 1.8078078082052054 -9.34758655780036 1.8108108112072072 -9.27889026367861 1.8138138142092093 -9.206890620832318 1.8168168172112114 -9.131613261629333 1.8198198202132134 -9.053084985327034 1.8228228232152153 -8.971333748531672 1.8258258262172173 -8.886388655245552 1.8288288292192194 -8.798279946505872 1.8318318322212213 -8.707038989618688 1.8348348352232233 -8.612698266991893 1.8378378382252254 -8.51529136457133 1.8408408412272272 -8.414852959883927 1.8438438442292293 -8.311418809692224 1.8468468472312314 -8.205025737264792 1.8498498502332335 -8.09571161926685 1.8528528532352353 -7.983515372275926 1.8558558562372374 -7.868476938927261 1.8588588592392394 -7.750637273694001 1.8618618622412413 -7.630038328307109 1.8648648652432434 -7.506723036820216 1.8678678682452454 -7.380735300324873 1.8708708712472473 -7.2521199713214255 1.8738738742492493 -7.1209228377511815 1.8768768772512514 -6.987190606695661 1.8798798802532533 -6.850970887748518 1.8828828832552553 -6.712312176066155 1.8858858862572574 -6.571263835103212 1.8888888892592595 -6.427876079038728 1.8918918922612613 -6.282199954899649 1.8948948952632634 -6.134287324387644 1.8978978982652654 -5.984190845416055 1.9009009012672673 -5.8319639533633 1.9039039042692694 -5.677660842049451 1.9069069072712714 -5.521336444442958 1.9099099102732733 -5.363046413104082 1.9129129132752754 -5.202847100372167 1.9159159162772774 -5.0407955383039 1.9189189192792795 -4.876949418369454 1.9219219222812813 -4.711367070913952 1.9249249252832834 -4.544107444391405 1.9279279282852855 -4.37523008437875 1.9309309312872873 -4.204795112377169 1.9339339342892894 -4.032863204408371 1.9369369372912915 -3.859495569413609 1.9399399402932933 -3.684753927462829 1.9429429432952954 -3.508700487781849 1.9459459462972974 -3.3313979266055633 1.9489489492992995 -3.15290936486464 1.9519519523013014 -2.973298345714169 1.9549549553033034 -2.792628811911727 1.9579579583053055 -2.6109650830534337 1.9609609613073073 -2.4283718326756847 1.9639639643093094 -2.2449140652308754 1.9669669673113115 -2.060657092945472 1.9699699703133133 -1.8756665125683583 1.9729729733153154 -1.6900081820178898 1.9759759763173175 -1.5037481969361266 1.9789789793193193 -1.316952867158279 1.9819819823213214 -1.1296886931058967 1.9849849853233235 -0.9420223421123661 1.9879879883253255 -0.7540206246888127 1.9909909913273274 -0.5657504707391345 1.9939939943293294 -0.37727890573242484 1.9969969973313315 -0.18867302684155113 2.0000000003333334 -2.0943952780677518e-08 2.0030030033353357 -0.18867306872201825 2.0060060063373375 -0.3772789475905083 2.0090090093393393 -0.5657505125599502 2.0120120123413416 -0.75402066645749 2.0150150153433435 -0.9420223838139995 2.0180180183453453 -1.1296887347256404 2.0210210213473476 -1.3169529086813514 2.0240240243493495 -1.5037482383477274 2.0270270273513513 -1.6900082233032585 2.0300300303533536 -1.8756665537128319 2.0330330333553555 -2.060657133934386 2.0360360363573573 -2.24491410604962 2.0390390393593596 -2.428371873309762 2.0420420423613614 -2.6109651234883606 2.0450450453633633 -2.792628852133092 2.0480480483653656 -2.9732983857076873 2.0510510513673674 -3.1529094046160555 2.0540540543693693 -3.331397966100708 2.0570570573713716 -3.508700527006712 2.0600600603733734 -3.684753966403397 2.0630630633753757 -3.859495608056051 2.0660660663773776 -4.032863242738914 2.0690690693793794 -4.204795150382151 2.0720720723813817 -4.375230122044673 2.0750750753833835 -4.5441074817048275 2.0780780783853854 -4.711367107861607 2.0810810813873877 -4.876949454938202 2.0840840843893895 -5.040795574480693 2.0870870873913914 -5.202847136144124 2.0900900903933937 -5.363046448458499 2.0930930933953955 -5.521336479367234 2.0960960963973974 -5.67766087653114 2.0990990993993996 -5.831963987390152 2.1021021024014015 -5.9841908789759435 2.1051051054034033 -6.134287357468606 2.1081081084054056 -6.282199987489938 2.1111111114074075 -6.427876111126725 2.1141141144094093 -6.571263866677483 2.1171171174114116 -6.712312207115496 2.1201201204134135 -6.850970918261837 2.1231231234154153 -6.987190636662108 2.1261261264174176 -7.120922867160101 2.1291291294194195 -7.252120000162322 2.1321321324214217 -7.380735328587504 2.1351351354234236 -7.506723064494497 2.1381381384254254 -7.630038355383198 2.1411411414274277 -7.750637300162271 2.1441441444294296 -7.868476964778265 2.1471471474314314 -7.983515397500463 2.1501501504334337 -8.09571164385597 2.1531531534354356 -8.205025761209715 2.1561561564374374 -8.311418832984419 2.1591591594394397 -8.414852982515125 2.1621621624414415 -8.515291386533466 2.1651651654434434 -8.612698288277135 2.1681681684454457 -8.707039010219477 2.1711711714474475 -8.798279966414867 2.1741741744494494 -8.886388674455656 2.1771771774514517 -8.971333767036064 2.1801801804534535 -9.053085003119119 2.1831831834554554 -9.131613278702766 2.1861861864574577 -9.206890637181042 2.1891891894594595 -9.278890279296787 2.192192192461462 -9.347586572682442 2.1951951954634636 -9.41295506098528 2.1981981984654655 -9.474972472574061 2.201201201467468 -9.533616728823917 2.2042042044694696 -9.588866951976442 2.2072072074714715 -9.640703472572364 2.2102102104734738 -9.689107836453992 2.2132132134754756 -9.734062811334995 2.2162162164774775 -9.775552392935271 2.2192192194794798 -9.81356181067854 2.2222222224814816 -9.848077532950764 2.2252252254834834 -9.879087271917534 2.2282282284854857 -9.906579987898594 2.2312312314874876 -9.930545893298039 2.2342342344894894 -9.95097645608879 2.2372372374914917 -9.96786440285004 2.2402402404934936 -9.981203721356636 2.2432432434954954 -9.990989662719485 2.2462462464974977 -9.99721874307619 2.2492492494994996 -9.999888744831312 2.2522522525015014 -9.998998717445875 2.2552552555035037 -9.994548977775748 2.2582582585055055 -9.986541109958843 2.261261261507508 -9.974977964851156 2.2642642645095097 -9.959863659011841 2.2672672675115115 -9.941203573237681 2.270270270513514 -9.9190043506475 2.2732732735155157 -9.893273894317158 2.2762762765175175 -9.864021364465994 2.27927927951952 -9.831257175195741 2.2822822825215217 -9.794992990783037 2.2852852855235235 -9.755241721526835 2.288288288525526 -9.712017519152264 2.2912912915275276 -9.665335771772547 2.2942942945295295 -9.61521309841067 2.297297297531532 -9.561667343082924 2.3003003005335336 -9.504717568446344 2.3033033035355355 -9.444384049012207 2.3063063065375378 -9.380688263928205 2.3093093095395396 -9.313652889331747 2.3123123125415415 -9.243301790277034 2.3153153155435438 -9.169660012238964 2.3183183185455456 -9.092753772196822 2.3213213215475474 -9.012610449300766 2.3243243245495497 -8.92925857512471 2.3273273275515516 -8.842727823508895 2.330330330553554 -8.75304899999578 2.3333333335555557 -8.66025403086307 2.3363363365575576 -8.564375951757716 2.33933933955956 -8.465448895935006 2.3423423425615617 -8.363508082106957 2.3453453455635636 -8.258589801904094 2.348348348565566 -8.150731406955444 2.3513513515675677 -8.039971295591155 2.3543543545695695 -7.926348899172311 2.357357357571572 -7.809904668053146 2.3603603605735737 -7.690680057180515 2.3633633635755755 -7.568717511335514 2.366366366577578 -7.444060450022912 2.3693693695795797 -7.316753252013575 2.3723723725815815 -7.1868412395451875 2.375375375583584 -7.0543706621872815 2.3783783785855857 -6.9193886803761595 2.3813813815875875 -6.781943348625297 2.38438438458959 -6.642083598417682 2.3873873875915916 -6.499859220785952 2.390390390593594 -6.355320848586269 2.3933933935955958 -6.20851993847284 2.3963963965975976 -6.059508752578878 2.3993993995996 -5.9083403399109615 2.4024024026016018 -5.755068517463309 2.4054054056036036 -5.599747851058401 2.408408408605606 -5.4424336359212475 2.4114114116076077 -5.283181876994004 2.4144144146096096 -5.122049268997645 2.417417417611612 -4.959093176248344 2.4204204206136137 -4.794371612235474 2.4234234236156156 -4.627943218968224 2.426426426617618 -4.45986724609873 2.4294294296196197 -4.290203529828887 2.4324324326216216 -4.119012471608064 2.435435435623624 -3.9463550166298624 2.4384384386256257 -3.7722926321353056 2.4414414416276276 -3.59688728552989 2.44444444462963 -3.4202014223228527 2.4474474476316317 -3.2422979438962445 2.4504504506336335 -3.063240185111407 2.453453453635636 -2.8830918917614383 2.4564564566376377 -2.7019171978772754 2.45945945963964 -2.5197806028954837 2.462462462641642 -2.336746948696049 2.4654654656436437 -2.152881396518173 2.468468468645646 -1.9682494037624363 2.471471471647648 -1.7829167006876423 2.4744744746496496 -1.5969492670101784 2.477477477651652 -1.4104133084148907 2.480480480653654 -1.2233752329855099 2.4834834836556556 -1.0359016275627062 2.486486486657658 -0.8480592340388214 2.4894894896596598 -0.6599149255974025 2.4924924926616616 -0.47153568290567716 2.495495495663664 -0.2829885702690805 2.4984984986656658 -0.09434071175600911 2.5015015016676676 -0.09434073269902249 2.50450450466967 -0.28298859120467357 2.5075075076716717 -0.47153570382632565 2.5105105106736736 -0.6599149464956942 2.513513513675676 -0.8480592549073338 2.5165165166776777 -1.0359016483939747 2.51951951967968 -1.2233752537721538 2.522522522681682 -1.4104133291494918 2.5255255256836837 -1.5969492876853204 2.528528528685686 -1.7829167212960346 2.531531531687688 -1.9682494242967072 2.5345345346896897 -2.152881416970977 2.537537537691692 -2.3367469690601754 2.540540540693694 -2.5197806231636473 2.5435435436956957 -2.7019172180422437 2.546546546697698 -2.883091911816049 2.5495495496997 -3.0632402050485035 2.5525525527017017 -3.2422979637087805 2.555555555703704 -3.4202014420037403 2.558558558705706 -3.59688730507209 2.5615615617077077 -3.772292651531894 2.56456456470971 -3.9463550358739665 2.567567567711712 -4.119012490692768 2.5705705707137136 -4.290203548747429 2.573573573715716 -4.459867264844405 2.576576576717718 -4.627943237534297 2.5795795797197196 -4.794371630615367 2.582582582721722 -4.959093194435543 2.5855855857237238 -5.1220492869856145 2.588588588725726 -5.283181894776402 2.591591591727728 -5.442433653491712 2.5945945947297298 -5.599747868410647 2.597597597731732 -5.755068534591219 2.600600600733734 -5.908340356808407 2.6036036037357357 -6.059508769239816 2.606606606737738 -6.208519954891393 2.60960960973974 -6.355320864756568 2.6126126127417417 -6.499859236702225 2.615615615743744 -6.642083614074302 2.618618618745746 -6.781943364016638 2.6216216217477477 -6.919388695496769 2.62462462474975 -7.0543706770318 2.627627627751752 -7.186841254108281 2.6306306307537537 -7.3167532662900845 2.633633633755756 -7.444060464007778 2.636636636757758 -7.56871752502371 2.6396396397597597 -7.690680070567193 2.642642642761762 -7.8099046811335615 2.645645645763764 -7.926348911941763 2.6486486487657657 -8.039971308045121 2.651651651767768 -8.150731419089507 2.65465465476977 -8.258589813713897 2.657657657771772 -8.363508093588335 2.660660660773774 -8.465448907083852 2.663663663775776 -8.564375962570042 2.666666666777778 -8.660254041335042 2.66966966977978 -8.75304901012369 2.6726726727817818 -8.84272783328911 2.675675675783784 -8.929258584553752 2.678678678785786 -9.012610458375278 2.6816816817877878 -9.092753780913595 2.68468468478979 -9.169660020594879 2.687687687791792 -9.243301798269103 2.6906906907937937 -9.313652896957139 2.693693693795796 -9.38068827118422 2.696696696797798 -9.444384055896235 2.6996996997997997 -9.504717574955945 2.702702702801802 -9.561667349215794 2.705705705803804 -9.615213104164603 2.7087087088058057 -9.665335777145504 2.711711711807808 -9.712017524142343 2.71471471480981 -9.75524172613224 2.717717717811812 -9.794992995002147 2.720720720813814 -9.831257179027045 2.723723723815816 -9.864021367908123 2.726726726817818 -9.893273897368895 2.72972972981982 -9.919004353307756 2.732732732821822 -9.941203575505508 2.735735735823824 -9.959863660886432 2.738738738825826 -9.974977966331842 2.741741741827828 -9.9865411110451 2.74474474482983 -9.994548978467186 2.747747747831832 -9.99899871774225 2.750750750833834 -9.999888744732516 2.753753753835836 -9.997218742582259 2.756756756837838 -9.9909896618306 2.75975975983984 -9.981203720073108 2.762762762841842 -9.967864401172324 2.765765765843844 -9.950976454017491 2.7687687688458458 -9.930545890833889 2.771771771847848 -9.906579985042468 2.77477477484985 -9.879087268670455 2.7777777778518518 -9.848077529313887 2.780780780853854 -9.81356180665315 2.783783783855856 -9.775552388522815 2.786786786857858 -9.734062806537032 2.78978978985986 -9.689107831272235 2.792792792861862 -9.640703467008665 2.795795795863864 -9.588866946032777 2.798798798865866 -9.533616722502389 2.801801801867868 -9.474972465876938 2.80480480486987 -9.412955053914938 2.807807807871872 -9.347586565241405 2.810810810873874 -9.278890271487708 2.813813813875876 -9.20689062900668 2.816816816877878 -9.131613270166055 2.81981981987988 -9.053084994223088 2.822822822881882 -8.971333757783864 2.825825825883884 -8.886388664850612 2.828828828885886 -8.798279956460382 2.831831831887888 -8.707038999919076 2.83483483488989 -8.612698277634523 2.837837837891892 -8.515291375552412 2.840840840893894 -8.41485297119952 2.843843843895896 -8.31141882133833 2.8468468468978982 -8.205025749237247 2.8498498498999 -8.095711631561409 2.852852852901902 -7.983515384888205 2.8558558559039042 -7.868476951852756 2.858858858905906 -7.750637286928135 2.861861861907908 -7.630038341845159 2.86486486490991 -7.50672305065735 2.867867867911912 -7.380735314456187 2.870870870913914 -7.25211998574188 2.873873873915916 -7.120922852455628 2.876876876917918 -6.987190621678891 2.87987987991992 -6.850970903005182 2.882882882921922 -6.7123121915908115 2.885885885923924 -6.571263850890347 2.888888888925926 -6.427876095082732 2.891891891927928 -6.282199971194773 2.89489489492993 -6.1342873409281236 2.897897897931932 -5.984190862196006 2.900900900933934 -5.831963970376703 2.903903903935936 -5.677660859290294 2.906906906937938 -5.521336461905102 2.90990990993994 -5.363046430781267 2.912912912941942 -5.202847118258145 2.9159159159439443 -5.040795556392304 2.918918918945946 -4.8769494366538115 2.921921921947948 -4.71136708938777 2.9249249249499503 -4.544107463048123 2.927927927951952 -4.3752301032117265 2.930930930953954 -4.204795131379651 2.9339339339559563 -4.03286322357364 2.936936936957958 -3.8594955887348448 2.93993993995996 -3.684753946933136 2.9429429429619622 -3.5087005073942787 2.945945945963964 -3.3313979463531505 2.948948948965966 -3.1529093847403717 2.9519519519679682 -2.9732983657109187 2.95495495496997 -2.7926288320224253 2.957957957971972 -2.6109651032709214 2.960960960973974 -2.428371852992713 2.963963963975976 -2.2449140856402634 2.966966966977978 -2.060657113439954 2.96996996997998 -1.875666533140585 2.972972972981982 -1.69000820266059 2.975975975983984 -1.5037482176419517 2.978978978985986 -1.316952887919805 2.981981981987988 -1.1296887139157845 2.9849849849899903 -0.9420223629631724 2.987987987991992 -0.7540206455731497 2.990990990993994 -0.5657504916495497 2.9939939939959963 -0.3772789266614561 2.996996996997998 -0.18867304778178318 3.0 -7.347880794884118e-15 )
Xmem0 SpiceNodeName.VIN n10 l0 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem1 SpiceNodeName.VIN n01 l1 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem2 n01 n11 l2 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem3 n01 n02 l3 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem4 n02 n12 l4 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem5 n02 n03 l5 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem6 n03 n13 l6 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem7 n10 n20 l7 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem8 n10 n11 l8 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem9 n11 n21 l9 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem10 n11 n12 l10 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem11 n12 n22 l11 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem12 n12 n13 l12 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem13 n13 n23 l13 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem14 n20 SpiceNodeName.GND l14 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem15 n20 n21 l15 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem16 n21 n31 l16 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem17 n21 n22 l17 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem18 n22 n32 l18 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem19 n22 n23 l19 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem20 n23 n33 l20 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem21 SpiceNodeName.GND n31 l21 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem22 n31 n32 l22 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
Xmem23 n32 n33 l23 memristor alpha=0 beta=500000.0 Roff=200000.0 Ron=2000.0 Rinit=200000.0 Vt=0.6
.tran 500.0 3 1e-09 uic
.control
run
set wr_vecnames
set wr_singlescale
wrdata /home/ignaciopineyro/MemNet/application/tmp_data/simulation_0_states.csv l0 l1 l2 l3 l4 l5 l6 l7 l8 l9 l10 l11 l12 l13 l14 l15 l16 l17 l18 l19 l20 l21 l22 l23
wrdata /home/ignaciopineyro/MemNet/application/tmp_data/simulation_0_iv.csv i(v1) vin
quit
.endc
.end
